Commit message: digit left arm needs refinement

File: digit/models/bag/bag.urdf (robot description, URDF)
Before this commit: robot bag, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=bag_vhacd.obj scale=0.5 0.7 0.8; visual mesh filename=bag2.obj scale=0.5 0.7 0.8
